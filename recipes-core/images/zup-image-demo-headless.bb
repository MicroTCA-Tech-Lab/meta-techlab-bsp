DESCRIPTION = "DAMC-FMC2ZUP Headless Linux Image"

IMAGE_AUTOLOGIN = "0"

require techlab-headless.inc
require zup-common.inc
